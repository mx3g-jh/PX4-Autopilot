## src/drivers/rpm/as5600/Kconfig
```kconfig
menuconfig DRIVERS_RPM_AS5600
	bool "as5600"
	default n
	---help---
		Enable support for as5600
```
